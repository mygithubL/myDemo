# Keil uVision project ZQ_STM32.uvprojx, settings and files
target ZQ_STM32 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ZQ_STM32 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\Lib\inc;.\System;.\USR;.\port;.\modbus\ascii;.\modbus\include;.\modbus\rtu;.\modbus\tcp;.\port
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group ASM
    ./ASM/: startup_stm32f10x_hd.s
  group USR
    ./USR/: main.c stm32f10x_it.c pbdata.c led.c uart.c
  group Lib
    ./Lib/SRC/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_exti.c misc.c
  group System
    ./System/: core_cm3.c system_stm32f10x.c
  group Modbus
    ./modbus/ascii/: mbascii.c
    ./modbus/functions/: mbfunccoils.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ./modbus/rtu/: mbcrc.c mbrtu.c
    ./modbus/tcp/: mbtcp.c
    ./modbus/: mb.c
  group port
    ./port/: portevent.c portserial.c porttimer.c
