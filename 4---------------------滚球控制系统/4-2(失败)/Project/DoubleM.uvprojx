# Keil uVision project DoubleM.uvprojx, settings and files
target DoubleM (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DoubleM
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USMART;..\USER;..\SYSTEM\sys;..\SYSTEM\usart;..\CORE;..\HARDWARE\TIMER;..\HARDWARE\EXTI;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\LED;..\HARDWARE\OV7670;..\STM32F10x_FWLib\inc;..\HARDWARE\HardWork;..\HARDWARE\EasyTrace;..\HARDWARE\MOTOR;..\HARDWARE\MPU6050;..\HARDWARE\MPU6050_DMP;..\HARDWARE\iic
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Lib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_fsmc.c stm32f10x_wwdg.c stm32f10x_iwdg.c stm32f10x_i2c.c
  group System
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group Usarmt
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group HardWare
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/OV7670/: ov7670.c sccb.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/HardWork/: HardWork.c
    ../HARDWARE/EasyTrace/: EasyTrace.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/MPU6050_DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/MPU6050/: mpu6050.c
    ../HARDWARE/iic/: iic.c
  group Core
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group User
    ../USER/: main.c pbdata.c stm32f10x_it.c system_stm32f10x.c wdg.c
