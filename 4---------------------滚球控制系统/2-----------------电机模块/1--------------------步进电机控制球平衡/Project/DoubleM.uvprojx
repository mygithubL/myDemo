# Keil uVision project DoubleM.uvprojx, settings and files
target DoubleM (ARM-ADS)
  device: STM32F103RD STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x60000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DoubleM
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Lib\inc;..\System;..\User;..\app\iic;..\app\led;..\app\MPU6050;..\app\MPU6050_DMP;..\app\usart1;..\app\motor;..\app\HC-SR04
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../User/: main.c pbdata.c stm32f10x_it.c wdg.c
  group Lib
    ../Lib/src/: misc.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_i2c.c stm32f10x_wwdg.c stm32f10x_exti.c
  group System
    ../System/: core_cm3.c system_stm32f10x.c
  group Startup
    ../startup/: startup_stm32f10x_hd.s
  group Doc
    ../Doc/: ReadMe.txt
  group app
    ../app/iic/: iic.c
    ../app/led/: led.c
    ../app/MPU6050/: mpu6050.c
    ../app/MPU6050_DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../app/usart1/: usart1.c
    ../app/motor/: motor.c
    ../User/: sys.c
